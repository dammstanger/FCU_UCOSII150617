# Keil uVision project STM32_PRO.uvproj, settings and files
target NEW_TEMP (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_PRO +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\APP;..\BSP;..\CMSIS;..\FWlib\inc;..\FWlib\src;..\USER;..\Startup;..\eMPL;..\HARDWARE;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group STARTUP
    ../Startup/: startup_stm32f10x_hd.s
  group LIB
    ../FWlib/src/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_exti.c stm32f10x_tim.c
  group BSP
    ../BSP/: BSP.c I2C_1.c spi.c usart.c SysTick.c EXTI.c Timer_PWMin.c Timer_PWMout.c
  group HARDWARE
    ../HARDWARE/: 24l01.c ADNS3080.c bmp085.c HMC5883.c led.c MPU.c OLED_MWC.c SR04.c
  group APP
    ../APP/: app.c AHRS.c Attitude.c ComProtocol.c Control.c DataProcess.c Inertial_nav.c myfunc.c Optical_Flow.c Quaternion.c RCdata.c Sonar.c Transmit.c app_cfg.h
  group USER
    ../USER/: main.c stm32f10x_it.c stm32f10x_conf.h
  group eMPL
    ../eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu.h os_cpu_a.asm
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_task.c os_time.c os_tmr.c os_sem.c
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group README
    ../: readme.txt
